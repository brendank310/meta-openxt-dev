
IMAGE_FEATURES += "\
    dev-pkgs \
    tools-sdk \
"

IMAGE_INSTALL += "\
    gcc \
    git \
    autoconf automake binutils binutils-symlinks cpp cpp-symlinks gcc gcc-symlinks g++ g++-symlinks gettext make libstdc++ libstdc++-dev file coreutils \
    gdb \
"

#    qtbase-tools \
